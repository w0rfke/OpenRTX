# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (6210000::V6.21::ARMCLANG)
  device: STM32F401VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F401xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c ST7735S_a36plus.c openrtxfunctions.c
    ../Core/Inc/: ST7735S.h
    ../../openrtx/include/interfaces/: display.h keyboard.h
    ../../openrtx/src/core/: graphics.c state.c utils.c cps.c battery.c crc.c input.c openrtx.c threads.c
    ../../openrtx/include/core/: graphics.h
    ../../openrtx/src/ui/default/: ui.c ui_main.c ui_menu.c ui_strings.c
    ../../platform/targets/A36Plus/: platform.c pinmap.h
    ../../platform/mcu/STM32F4xx/drivers/: gpio-native.h gpio.c
    ../../openrtx/src/rtx/: rtx.cpp OpMode_FM.cpp
    ../../platform/drivers/keyboard/: keyboard_a36plus.c
    ../../platform/drivers/CPS/: cps_io_native_A36plus.c
    ../../platform/drivers/NVM/: spiFlash_A36plus.c nvmem_A36Plus.c W25Qx.c
    ../../platform/drivers/baseband/: radio_A36Plus.cpp
    ../Core/: keep_old_functions.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 6.1.0
